# Autodesk Inventor part: 커버
## iProperties
Created: 2014-03
Part Number: 커버
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
